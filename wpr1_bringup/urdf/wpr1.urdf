Commit message: update urdf for simulation

File: wpr1_bringup/urdf/wpr1.urdf (robot description, URDF)
Before this commit: robot WPR1, 12 links, 11 joints
Links:
- link base_footprint: mass 10 -> None
- link kinect2_dock: geometry visual box size=0 0 0
